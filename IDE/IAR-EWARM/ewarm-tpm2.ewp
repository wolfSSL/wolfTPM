# IAR project ewarm-tpm2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: WOLFTPM2_NO_WOLFCRYPT
  ICCARM.CCIncludePath2: ..\..; header
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ewarm-tpm2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group header
    header/: tpm_main.h
  group lib/wolftpm
    ../../src/: tpm2.c tpm2_packet.c tpm2_tis.c tpm2_wrap.c
  group source
    source/: main.c tpm_main.c
