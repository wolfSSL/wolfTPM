# Keil uVision project wolfTPM.uvprojx, settings and files
target wolfTPM-demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F479IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: WOLFSSL_USER_SETTINGS
  c misc: --diag_suppress=66
  c include: ..\..\..\wolfTPM;.\RTE\wolfSSL;..\OPENSTM32\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group src
    ../../src/: tpm2_packet.c tpm2_tis.c tpm2_wrap.c tpm2.c
  group examples
    ../../examples/wrap/: wrap_test.c
    ../OPENSTM32/Src/: main.c wolftpm_example.c
    ../../examples/: tpm_io.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:CRYP 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:HASH 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:RNG 1.7.4, Device:STM32Cube HAL:RTC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:Startup 2.6.2, wolfSSL:wolfCrypt:Benchmark 3.14.0, wolfSSL:wolfCrypt:CORE 3.14.0, wolfSSL:wolfCrypt:Dummy 3.14.0, wolfSSL:wolfCrypt:Test 3.14.0
